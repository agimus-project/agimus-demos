Commit message: Pipeline hpp -> mpc -> lfc works with both arms in simu

File: agimus_demo_10_tiago_pro_bar_manip/urdf/environment.urdf (robot description, URDF)
Before this commit: robot empty_env, 0 links, 0 joints
Links:
- added link empty_env_base_link
