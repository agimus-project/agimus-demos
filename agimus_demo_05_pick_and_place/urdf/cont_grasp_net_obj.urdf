Commit message: Remove box from the state, make a static obstacle

File: agimus_demo_05_pick_and_place/urdf/cont_grasp_net_obj.urdf (robot description, URDF)
Before this commit: robot cont_grasp_net_obj, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=0.01 0.01 0.01
