Commit message: revert changes to demo_05 from contactgraspnet experiment

File: agimus_demo_05_pick_and_place/urdf/big_box.urdf (robot description, URDF)
Before this commit: robot big_box, 2 links, 1 joints
Links:
- removed link fake_base_link
Joints:
- removed joint fake_joint
