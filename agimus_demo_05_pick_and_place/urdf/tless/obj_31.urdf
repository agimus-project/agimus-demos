Commit message: add possibility to use apriltag

File: agimus_demo_05_pick_and_place/urdf/tless/obj_31.urdf (robot description, URDF)
Before this commit: robot object, 2 links, 1 joints
Joints:
- joint tag_to_box: origin xyz=0 -0.024 -0.03 -> xyz=-0.024 0.03 0.0 rpy=1.57 1.57 0 
